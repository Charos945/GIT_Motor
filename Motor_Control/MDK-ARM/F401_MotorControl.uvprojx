# Keil uVision project F401_MotorControl.uvprojx, settings and files
target F401_MotorControl (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: F401_MotorControl +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MEM_UNIT_BYTES,ARM_MATH_CM4,MemUnit_T=uint8_T,MATLAB_PROJECT,USE_HAL_DRIVER,STM32F401xE,__FPU_PRESENT
  c include: ../Inc;                                                                         ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                                         ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                                         ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                                         ../Drivers/CMSIS/Include;                                                                         ../Drivers/CMSIS/Core/Include;                                                                         ../Drivers/CMSIS/DSP/Include;                                                                         ../MotorControl/Inc;                                                                         "../../../Program Files/Polyspace/R2019b/simulink/include";                                                                         ..\Motor_Control_ert_rtw
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_crc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Simulink_Code
    ../Motor_Control_ert_rtw/: Angle_Speed_100us.c Control_Command_2ms.c FOC_Control_100us.c HF_Observer.c Motor_Control.c Motor_Control_data.c Motor_State_10ms.c Resolver_Angle_cacl.c rt_nonfinite.c rt_sys_HF_Observer_37.c rt_sys_HF_Observer_38.c rtGetInf.c rtGetNaN.c SMO_Function_wrapper.c SpeedAndAngle.c
software components: CMSIS:CORE 4.3.0
